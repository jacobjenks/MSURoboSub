Commit message: Added mission pause button (p).

File: msurobosub_ros/src/msurobosub/robosub_model.urdf (robot description, URDF)
Before this commit: robot robosub, 7 links, 6 joints
Links:
- link base_link: geometry visual mesh filename=package://msurobosub/misc/robosub.stl
